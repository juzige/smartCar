# IAR project SeekFree_Kinetis.ewp, settings and files
configuration MK60DN_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MK60DN; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MK60FX; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option; ..\..\..\Libraries\app\inc
  ILINK.IlinkIcfFile: linker\MK60xX512_15.icf
  group app/inc
    ../../../Libraries/app/inc/: adjparameter.h anjian.h camara.h control.h myapp.h SEEKFREE_VIRSCO.h variadle.h WJ_STAR_IMAGE.h
  group app/scr
    ../../../Libraries/app/src/: adjparameter.c anjian.c camara.c control.c myapp.c SEEKFREE_VIRSCO.c variadle.c WJ_STAR_IMAGE.c
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group seekfree
    ../../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s startup_MK60F15.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60.c
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/: version.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
